FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@FIT_DTB_IMAGE_NAME@@:${FIT_DTB_IMAGE_NAME}:'"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@FIT_IMAGE_PARTITION_A@@:${FIT_IMAGE_PARTITION_A}:'"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@FIT_IMAGE_PARTITION_B@@:${FIT_IMAGE_PARTITION_B}:'"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@ROOTFS_PARTITION_A@@:${ROOTFS_PARTITION_A}:'"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@ROOTFS_PARTITION_B@@:${ROOTFS_PARTITION_B}:'"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@RAUC_SLOT_A@@:${RAUC_SLOT_A}:'"
SCRIPT_SED_ADDENDUM:append = " -e 's:@@RAUC_SLOT_B@@:${RAUC_SLOT_B}:'"
