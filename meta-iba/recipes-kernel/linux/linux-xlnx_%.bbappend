FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://rauc-base.cfg"
SRC_URI += "file://rauc-streaming.cfg"
SRC_URI += "file://rauc-verity.cfg"
