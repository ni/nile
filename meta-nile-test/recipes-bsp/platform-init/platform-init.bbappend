FILESEXTRAPATHS:prepend := "${THISDIR}/platform-init:"

