LINUX_VERSION = "6.12.94"

KBRANCH = "nilrt/master/6.12"
SRCREV = "91411b5d605ff59dbb43b35bbc9235c4a78849a5"

YOCTO_KMETA_BRANCH = "yocto-6.12"
SRCREV_meta = "c2c79110dc202f883e29a94004ce346b6dd0ccb7"

include linux-nilrt.inc
