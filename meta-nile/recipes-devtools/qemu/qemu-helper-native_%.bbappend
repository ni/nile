do_addto_recipe_sysroot[cleandirs] = "${RECIPE_SYSROOT_NATIVE}"
